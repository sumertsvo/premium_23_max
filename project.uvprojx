# Keil uVision project project.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: -AT32F403ARCT7 ArteryTek
  pack: ArteryTek.AT32F403A_407_DFP.2.0.8
  cpu: IRAM(0x20000000,0x38000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x38000
  group my
    ./: main.c at32f403a_407_clock.c
software components: CMSIS:CORE 5.6.0, Device:at32f403a_407_conf 2.0.0, Device:at32f403a_407_firmware_library:adc 2.0.0, Device:at32f403a_407_firmware_library:crm 2.0.0, Device:at32f403a_407_firmware_library:flash 2.0.0, Device:at32f403a_407_firmware_library:gpio 2.0.0, Device:at32f403a_407_firmware_library:misc 2.0.0, Device:at32f403a_407_firmware_library:rtc 2.0.0, Device:at32f403a_407_firmware_library:spi 2.0.0, Device:at32f403a_407_firmware_library:tmr 2.0.0, Device:at32f403a_407_firmware_library:usart 2.0.0, Device:at32f403a_407_firmware_library:wdt 2.0.0, Device:startup 2.0.0
